# Keil uVision project Template.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\KEY;..\HARDWARE\ETHERNET;..\HARDWARE\TIMER;..\HARDWARE\LED;..\HARDWARE\SRAM;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\HARDWARE\InterTemperate;..\HARDWARE\ADC;..\MALLOC;..\LWIP;..\LWIP\arch;..\LWIP\lwip_header;..\LWIP\app\TCP_Client;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\web_server_demo;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\snmp;..\FWLIB\STM32F10x_StdPeriph_Driver\inc;..\FWLIB\STM32_ETH_Driver\inc;..\LWIP\lwip_app\udp;..\LWIP\lwip_app\ptp;..\HARDWARE\IIC;..\SYSTEM\type;..\HARDWARE\STMFLASH;..\HARDWARE\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c callback.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ETHERNET/: LAN8720.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/IWDG/: iwdg.c
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f107xc.s
  group FWLIB
    ../FWLIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c
    ../FWLIB/STM32_ETH_Driver/src/: stm32_eth.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c cmd_handle.c
    ../SYSTEM/type/: type.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group MALLOC
    ../MALLOC/: malloc.c
  group LWIP_SNMP
    ../LWIP/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group SNMP
    ../LWIP/snmp/: lwip_prvmib.c
  group PTP
    ../LWIP/lwip_app/ptp/: common.c ptp.c ptp_hardware.c systime.c
    ../LWIP/lwip_app/udp/: udp_echoserver.c
